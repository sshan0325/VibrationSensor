# IAR project Test_170920.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; ARM_MATH_CM4
  ICCARM.CCIncludePath2: D:\01_Work\90_IARProject\VibrationSensor\IAR Embedded Workbench\Libraries\CMSIS\Include; D:\01_Work\90_IARProject\VibrationSensor\IAR Embedded Workbench\Libraries\CMSIS\ST\STM32F4xx\Include; D:\01_Work\90_IARProject\VibrationSensor\IAR Embedded Workbench\Libraries\STM32F4xx_StdPeriph_Driver\inc; D:\01_Work\90_IARProject\VibrationSensor\IAR Embedded Workbench\Libraries\STM32F4xx_StdPeriph_Driver\src; D:\01_Work\90_IARProject\VibrationSensor\IAR Embedded Workbench\Utilities\STM32F4-Discovery; D:\01_Work\90_IARProject\VibrationSensor\User; D:\01_Work\90_IARProject\VibrationSensor\Common\Include; D:\01_Work\90_IARProject\VibrationSensor\Common\Source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Test_170920.bin
  ILINK.IlinkOutputFile: Test_170612_2.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f407xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group EWARM
    IAR Embedded Workbench/Libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group STM32F4-Discovery
    IAR Embedded Workbench/Utilities/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_lis302dl.c
  group STM32F4xx_StdPeriph_Driver
    IAR Embedded Workbench/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    User/: main.c set_DAC.c set_LIS302DL.c stm32f4xx_conf.h stm32f4xx_it.c system_stm32f4xx.c
